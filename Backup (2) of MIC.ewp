# IAR project Backup (2) of MIC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; driver\inc; Utilities\STM8S_EVAL
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MIC.hex
  ILINK.IlinkOutputFile: MIC.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group driver
    driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_i2c.c stm8s_uart1.c
  group source
    ./: main.c stm8s_it.c
